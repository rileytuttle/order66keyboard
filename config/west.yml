## order66-lp/zmk/boards/shields/order66_lp/Kconfig.shield
```kconfig
# SPDX-License-Identifier: MIT

config SHIELD_ORDER66_LP
    def_bool $(shields_list_contains,order66_lp)
```
